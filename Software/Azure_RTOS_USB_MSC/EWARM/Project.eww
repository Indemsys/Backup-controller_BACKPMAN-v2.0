<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Azure_RTOS_USB_MSC.ewp</path>
  </project>
  <batchBuild />
</workspace>
